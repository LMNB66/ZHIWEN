# Keil uVision project fingerprint.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x2800) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_LD,__USE_C99_MATH
  c misc: --C99 --locale=english
  c include: .\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\Drive\UART;.\Drive\servo;.\Drive\ADC;.\Drive\beep;.\Drive\key;.\Drive\OLED;.\Drive\show;.\Drive\SPI;.\Drive\stopmode;.\Drive\led
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group DRIVE
    ./Drive/UART/: UART.c
    ./Drive/ADC/: ADC.c
    ./Drive/beep/: beep.c
    ./Drive/key/: key.c
    ./Drive/OLED/: gui.c oled.c
    ./Drive/servo/: servo.c
    ./Drive/show/: show.c
    ./Drive/SPI/: spi.c
    ./Drive/stopmode/: stopmode.c
    ./Drive/led/: led.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
